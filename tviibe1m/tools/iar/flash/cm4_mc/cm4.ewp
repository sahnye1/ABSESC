# IAR project cm4.ewp, settings and files
configuration rev_b (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: tviibe1m; CYT2B78CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_b
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_b; ..\..\..\..\hdr\rev_b\ip; ..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_b; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm4.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibe1m; CYT2B78CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_c
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_c; ..\..\..\..\hdr\rev_c\ip; ..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_c; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_c
configuration rev_d (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CYT2B7_M4 Infineon CYT2B7_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: tviibe1m; CYT2B75CAE; CY_USE_PSVP=0; CY_MCU_rev_d
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d; ..\..\..\..\src\PSW; ..\..\..\..\src\PSW\in; ..\..\..\..\src\PSW\test; ..\..\..\..\src\PSW\Drive
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
configuration starter_kit (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: tviibe1m; CYT2B75BAE; CY_USE_PSVP=0; STARTER_KIT_REV3; CY_MCU_rev_d
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
configuration rtos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibe1m; CYT2B78CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_d
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\..\common\src\rtos\include; ..\..\..\..\..\common\src\rtos\portable\IAR\ARM_CM4F; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d
  AARM.AUserIncludes: ..\..\..\..\..\common\src\rtos\include
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_d
    ../../../../hdr/rev_d/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h bb_bsp_tviibe1m_starter_kit.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_d/ip
    ../../../../hdr/rev_d/ip/: cyip_backup_v2.h cyip_canfd.h cyip_coredefines.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group src/drivers/adc
    ../../../../../common/src/drivers/adc/: cy_adc.c cy_adc.h
  group src/drivers/canfd
    ../../../../../common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group src/drivers/cpu
    ../../../../src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group src/drivers/dma
    ../../../../../common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group src/drivers/gpio
    ../../../../../common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group src/drivers/scb
    ../../../../../common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group src/drivers/sysclk
    ../../../../src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group src/drivers/sysint
    ../../../../../common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group src/drivers/syslib
    ../../../../../common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../../../common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group src/drivers/sysreset
    ../../../../../common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group src/drivers/systick
    ../../../../../common/src/drivers/systick/: cy_systick.c cy_systick.h
  group src/drivers/syswdt
    ../../../../../common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group src/drivers/tcpwm
    ../../../../../common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group src/drivers/trigmux
    ../../../../../common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group src/interrupts/rev_d
    ../../../../src/interrupts/rev_d/: cy_interrupt_map.c cy_interrupt_map_cm4.h
  group src/PSW
    ../../../../src/PSW/Drive/: adc.c adc.h bts724g.c bts724g.h can.c can.h eeprom.c eeprom.h gpio.c gpio.h peri_div.h spi_eeprom.c spi_eeprom.h timer10ms.c timer10ms.h valve_pwm.c valve_pwm.h wheel_speed.c wheel_speed.h
    ../../../../src/PSW/: cmn.c cmn.h psw_log.c psw_log.h J1939_Com_Types.h psw_data.c psw_data.h RTE.h rte_psw.c rte_psw.h
  group src/PSW/inc
    ../../../../src/PSW/inc/: PSW_api.h
  group src/test
    ../../../../src/PSW/test/: PSWdebug.c PSWdebug.h PSWoem.c PSWoem.h PSWfactory.c PSWfactory.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm4.s
  group src/system/rev_d
    ../../../../src/system/rev_d/: system_cyt2b7.h system_tviibe1m_cm4.c
